## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="Totalplay-4BAA"
CONFIG_EXAMPLE_WIFI_PASSWORD="4BAA7E304XKDfKxd"
CONFIG_BROKER_URI="mqtts://l46d1e5e.ala.us-east-1.emqxsl.com:8883"
```
